# Keil uVision project FM33LG0XX_Tester.uvprojx, settings and files
target Example (6090000::V6.9::.\ARMCLANG)
  device: FM33LG04X FMSH
  pack: FMSH.FM33LG0XX_DFP.3.0.1
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: FM33LC0xx_Tester +hex
  c flags: Optim=1 OneElfS=1 v6Lang=6 wLevel=3
  c define: FM33LG0XX,USE_FULL_ASSERT
  c include: ..\Drivers\CMSIS\Inculde;..\Drivers\CMSIS\Device\FM\FM33xx\Include;..\Drivers\FM33LG0xx_FL_Driver\Inc;..\MF-config\Inc;..\Inc;..\MDK-ARM\radio;..\Inc\Peripheral\uart;..\Inc;..\Components\EasyLogger\easylogger\inc;..\Components\EasyLogger\easylogger\plugins\file;..\Components\EasyLogger\easylogger\plugins\flash;..\Components\EasyLogger;..\Components\FlashDB;..\Components\FlashDB\inc;..\Components\FlashDB\port\fal\inc;..\Components\LedIndicator;..\Components\Protocol;..\Components\Protocol\PC;..\Components\Protocol\Device;..\Components\Protocol\Device\Diomestic\DiaphragmGasMeters;..\Components\TimeManager;..\Components\Utility;..\Components\ValveCtrl;..\Components;..\Src\Test\Domestic_water_meter_Test;..\Src\Test\NB_18_DiaphragmGas_Test;..\Src\Test;..\Src\Test;..\Components\FlashDB\port\fal\inc;../Src
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application/MDK-ARM
    ../Drivers/CMSIS/Device/FM/FM33xx/Source/Templates/ARM/: startup_fm33lg0xx.s
  group Application/MF-config
    ../MF-config/Src/: mf_config.c
  group Application/User
    ../Src/: main.c time.c GPIO.c LED_CTRL.c ADC_CHK.c ina219.c WTD.c jiliang_xieyi_Ctrl.c tongxin_xieyi_irda_Ctrl.c elog_port.c tongxin_xieyi_Ctrl.c
    ../Src/Peripheral/uart/: uart0.c uart1.c uart3.c uart4.c
    ../Src/Test/: common_test_configure.c
    ../Src/Test/Domestic_water_meter_Test/: domestic_water_meter_test.c domestic_water_meter_test_utf8.c
    ../Src/Test/NB_18_DiaphragmGas_Test/: diaphragme_meter_test.c NB_18_DiaphragmGas_board_config.c NB_18_DiaphragmGas_board_debug.c NB_18_DiaphragmGas_port.c
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/FM/FM33xx/Source/: system_fm33lg0xx.c
  group Drivers/FM33LG0xx_FL_Driver
    ../Drivers/FM33LG0xx_FL_Driver/Src/: fm33lg0xx_fl.c fm33lg0xx_fl_adc.c fm33lg0xx_fl_aes.c fm33lg0xx_fl_atim.c fm33lg0xx_fl_bstim16.c fm33lg0xx_fl_bstim32.c fm33lg0xx_fl_can.c fm33lg0xx_fl_cmu.c fm33lg0xx_fl_comp.c fm33lg0xx_fl_crc.c fm33lg0xx_fl_dac.c fm33lg0xx_fl_divas.c fm33lg0xx_fl_dma.c fm33lg0xx_fl_exti.c fm33lg0xx_fl_flash.c fm33lg0xx_fl_gpio.c fm33lg0xx_fl_gptim.c fm33lg0xx_fl_i2c.c fm33lg0xx_fl_iwdt.c fm33lg0xx_fl_lcd.c fm33lg0xx_fl_lptim16.c fm33lg0xx_fl_lptim32.c fm33lg0xx_fl_lpuart.c fm33lg0xx_fl_opa.c fm33lg0xx_fl_pgl.c fm33lg0xx_fl_pmu.c fm33lg0xx_fl_rng.c fm33lg0xx_fl_rtca.c fm33lg0xx_fl_rtcb.c fm33lg0xx_fl_spi.c fm33lg0xx_fl_svd.c fm33lg0xx_fl_u7816.c fm33lg0xx_fl_uart.c fm33lg0xx_fl_vao.c fm33lg0xx_fl_wwdt.c fm33lg0xx_fl_vrefp.c
  group Components
    ../Components/EasyLogger/: EasyLogger.c
    ../Components/EasyLogger/easylogger/src/: elog.c elog_async.c elog_buf.c elog_utils.c
    ../Components/EasyLogger/easylogger/plugins/file/: elog_file.c elog_file_port.c
    ../Components/EasyLogger/easylogger/plugins/flash/: elog_flash_port.c
    ../Components/FlashDB/: fal_flash_fm33lg04_port.c flash_diag.c test_stats.c
    ../Components/FlashDB/src/: fdb.c fdb_file.c fdb_kvdb.c fdb_tsdb.c fdb_utils.c
    ../Components/FlashDB/port/fal/src/: fal.c fal_flash.c fal_partition.c fal_rtt.c
    ../Components/LedIndicator/: led_indicator.c
    ../Components/Protocol/: protocol_manager.c system_reset.c upgrade_magic.c upgrade_storage.c
    ../Components/Protocol/PC/: pc_protocol_common.c pc_protocol_config.c pc_protocol_upgrade.c
    ../Components/Protocol/PC/Domestic/DiaphragmGasMeters/: pc_protocol_diaphragm_gas_meter.c
    ../Components/Protocol/Device/Diomestic/DiaphragmGasMeters/: device_protocol_diaphragm_gas_meter.c
    ../Components/Protocol/Device/Diomestic/WaterMeters/: device_protocol_water_meter.c
    ../Components/Protocol/PC/Domestic/WaterMeters/: pc_protocol_water_meter.c
    ../Components/TimeManager/: retry_manager.c time_manager.c
    ../Components/Utility/: test_step_strings.c utility_convert.c utility_crc.c utility_filter.c
    ../Components/ValveCtrl/: valve_ctrl_core.c valve_ctrl_port.c
    ../Components/: components.c
